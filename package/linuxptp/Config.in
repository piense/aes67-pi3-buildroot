## package/linuxptp/Config.in
```kconfig
config BR2_PACKAGE_LINUXPTP
	bool "linuxptp"
	help
		ptp daemon, needs kernel support. 
```
